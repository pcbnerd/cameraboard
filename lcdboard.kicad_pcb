# Repository pcbnerd/cameraboard

## KiCad design lcdboard.kicad_pcb

Parts:
BT1, BT2, BT3: Battery_Cell; BAT_AAA_Keystone_55_56; MPN 55
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C14, C17, C18, C19: 0.1uF; C_0402_1005Metric; MPN C0402C104K4RAC7411
C11, C12, C13: 1uF; C_0402_1005Metric; MPN C1005X5R1V105K050BE
C15: 4.7uF; C_0805_2012Metric; MPN 0805B475K6R3CT
C16: 1uF; C_0805_2012Metric
C20, C21: 22pF; C_0402_1005Metric; MPN C0402C104K4RAC7411
D0, D2, D4, D5, D6, D7: D_Schottky; D_SOT-23_ANK; MPN BAT54SHMFHT116
D1: LED; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN SML-D12P8WT86C
J1, J5: Conn_01x06; PinHeader_1x06_P2.54mm_Horizontal
J2: Conn_02x25_Counter_Clockwise; LCD_ER-TFT035-6; MPN 541045031
J3: Conn_02x12_Counter_Clockwise; OV5640-5MP-Camera; MPN 687124183722
J4: USB_B_Micro; USB_Micro-B_Molex_47346-0001; MPN 47346-0001
J6: Conn_01x02; PinHeader_1x02_P2.54mm_Horizontal
L1: 4.7uH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder; MPN KLZ2012MHR4R7WTD25
R1, R10, R12, R14: DNP; R_0402_1005Metric
R2, R3: 10K; R_0402_1005Metric; MPN SFR01MZPF1002
R4: 0; R_0402_1005Metric; MPN CRCW04024K70JNEDC
R5: 1M; R_0402_1005Metric; MPN CRCW04024K70JNEDC
R6, R7, R8, R11, R13, R15, R16, R18, R24, R25: 4.7K; R_0402_1005Metric; MPN CRCW04024K70JNEDC
R19: 2R / 1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; MPN ERJ-6DQJ2R0V
R20: 91; R_0402_1005Metric; MPN ERJ-2RKF91R0X
R21, R22, R23: 33; R_0402_1005Metric; MPN CRCW040233R0JNEDC
RP1, RP2, RP3, RP4, RP5, RP6: 200; R_Array_Concave_4x0402
SW1: SW_Push; TACTILE_SWITCH_SMD_6.0X3.5MM; MPN KSR251GLFS
SW3: SW_SPST; SWITCH_SPST_SMD_A; MPN PCM12SMTR
TP3, TP5, TP6, TP7: TestPoint; TestPoint_Pad_D1.5mm
U1: MK82FN256VLL15; MPN MK82FN256VLL15
U2: Serial-Flash; WSON8-6X5MM; MPN IS25WP016D-JKLE
U3: TPS61169; SC70-5; MPN TPS61169DCKR
Y1: 32.768KHz; Crystal_SMD_EuroQuartz_EQ161-2Pin_3.2x1.5mm; MPN ECS-.327-12.5-34B-TR
Y2: 12MHz; Oscillator_SMD_EuroQuartz_XO53-4Pin_5.0x3.2mm_HandSoldering; MPN SM11T-22-12.0M-30H1CG

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C14.1, D5.2 (A), J2.13, J2.40, J2.41, J2.42, J3.4, J3.10, J3.11, R2.1, R3.1, R6.1, R7.1, R8.1, R10.1, R11.1, R12.1, R16.1, R24.1, R25.1, U1.6 (VDDIO_E), U1.15 (VDDIO_E), U1.19 (VOUT33), U1.22 (VDDA), U1.34 (VDD), U1.48 (VDD), U1.61 (VDD), U1.75 (VDD), U1.89 (VDD), U1.99 (VDD), U2.8 (VCC)
/+5V0: J5.3, J6.1
/BKLT_A: C16.1, D7.1 (K), J2.1, TP5.1
/BKLT_K: J2.2, J2.3, R19.1, TP7.1, U3.3 (FB)
/BKLT_PWM: R18.1, TP6.1, U1.77 (PTC5), U3.4 (CTRL)
/CAM_D0: J3.24, U1.93 (PTD2)
/CAM_D1: J3.23, U1.94 (PTD3)
/CAM_D2: J3.19, U1.87 (PTC15)
/CAM_D3: J3.21, U1.86 (PTC14)
/CAM_D4: J3.22, U1.83 (PTC11)
/CAM_D5: J3.20, U1.82 (PTC10)
/CAM_D6: J3.18, U1.81 (PTC9)
/CAM_D7: J3.16, U1.80 (PTC8)
/CAM_D8: J3.14, U1.79 (PTC7)
/CAM_D9: J3.12, U1.78 (PTC6)
/CAM_HREF: J3.9, U1.92 (PTD1)
/CAM_PCLK: J3.17, U1.91 (PTD0)
/CAM_PWRDN: J3.8, U1.95 (PTD4)
/CAM_RST_b: J3.6, U1.97 (PTD6)
/CAM_SIO_C: J3.5, U1.10 (PTE7)
/CAM_SIO_D: J3.3, R16.2, U1.11 (PTE8)
/CAM_VSYNC: J3.7, U1.96 (PTD5)
/CAM_XCLK1: J3.13, R4.1
/CTP_INT: C19.1, RP3.6, U1.9 (PTE6)
/CTP_RST_b: C18.1, RP3.5, U1.12 (PTE9)
/CTP_SCL: R25.2, RP3.8, U1.14 (PTE11)
/CTP_SDA: R24.2, RP3.7, U1.13 (PTE10)
/DISP_CSX: RP4.5, U1.71 (PTC1)
/DISP_DB0: RP5.5, U1.67 (PTB21)
/DISP_DB1: RP5.6, U1.66 (PTB20)
/DISP_DB2: RP5.7, U1.65 (PTB19)
/DISP_DB3: RP5.8, U1.64 (PTB18)
/DISP_DB4: RP6.5, U1.59 (PTB11)
/DISP_DB5: RP6.6, U1.58 (PTB10)
/DISP_DB6: RP6.7, U1.56 (PTB3)
/DISP_DB7: RP6.8, U1.55 (PTB2)
/DISP_DB8: RP2.1, U1.54 (PTB1)
/DISP_DB9: RP2.2, U1.53 (PTB0)
/DISP_DB10: RP2.3, U1.47 (PTA17)
/DISP_DB11: RP2.4, U1.46 (PTA16)
/DISP_DB12: RP1.1, U1.45 (PTA15)
/DISP_DB13: RP1.2, U1.44 (PTA14)
/DISP_DB14: RP1.3, U1.43 (PTA13)
/DISP_DB15: RP1.4, U1.42 (PTA12)
/DISP_DCX: RP4.6, U1.70 (PTC0)
/DISP_IM0: J2.7, R10.2, R13.1, U1.72 (PTC2)
/DISP_IM1: J2.8, R11.2, R14.1
/DISP_IM2: J2.9, R12.2, R15.1
/DISP_RDX: RP4.8, U1.68 (PTB22)
/DISP_RESET_b: J2.10, U1.57 (PTB9)
/DISP_WRX: RP4.7, U1.69 (PTB23)
/EXTAL0: C20.1, R5.1, U1.50 (PTA18/EXTAL0), Y2.3
/JTAG_TCLK: J1.3, U1.36 (PTA0/JTAG_TCLK)
/JTAG_TDI: J1.5, U1.37 (PTA1/JTAG_TDI)
/JTAG_TDO: J1.2, U1.38 (PTA2/JTAG_TDO)
/JTAG_TMS: J1.4, U1.39 (PTA3/JTAG_TMS)
/JTAG_TRST: R8.2, U1.41 (PTA5)
/NMI_b: C12.1, R1.1, R2.2, TP3.1, U1.40 (NMI_b)
/QSPIA_CLK: U1.2 (PTE1), U2.6 (SCK)
/QSPIA_CS_b: R6.2, U1.8 (PTE5), U2.1 (~CS~)
/QSPIA_D0: U1.3 (PTE2), U2.5 (SI(D0))
/QSPIA_D1: U1.7 (PTE4), U2.2 (SO(D1))
/QSPIA_D2: U1.4 (PTE3), U2.3 (~WP~(D2))
/QSPIA_D3: R7.2, U1.1 (PTE0), U2.7 (~HOLD~(D3))
/RST_b: C13.1, R3.2, SW1.1, U1.52 (RESET_b)
/UART_RX: J5.4, U1.62 (PTB16)
/UART_TX: J5.5, U1.63 (PTB17)
/USB_D+: R21.2, U1.17 (USB_DP)
/USB_D-: R22.2, U1.18 (USB_DM)
/USB_OTG_ID: R23.2, U1.100 (PTD7)
/VBAT: BT3.1 (+), SW3.2 (B), U1.33 (VBAT)
/VDD_REGIN: C10.1, C11.1, C15.1, D4.1 (K), D6.1 (K), L1.1, SW3.1 (A), U1.20 (VREGIN), U1.26 (ADC0_DP1), U3.5 (VIN)
/VREF: C17.1, U1.23 (VREFH), U1.28 (VREF_OUT)
/XTAL0_12MHZ: C21.1, R4.2, R5.2, U1.51 (PTA19/XTAL0), Y2.1
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, D1.1 (K), J1.1, J2.11, J2.12, J2.14, J2.15, J2.16, J2.34, J2.43, J2.48, J2.49, J2.50, J3.2, J3.15, J4.5 (GND), J4.6 (Shield), J5.1, R1.2, R13.2, R14.2, R15.2, R18.2, R19.2, SW1.2, U1.5 (VSS), U1.16 (VSS), U1.24 (VREFL), U1.25 (VSSA), U1.27 (ADC0_DM1), U1.35 (VSS), U1.49 (VSS), U1.60 (VSS), U1.74 (VSS), U1.88 (VSS), U1.98 (VSS), U2.4 (GND), U3.2 (GND), Y2.2, Y2.4
unnamed: BT1.1 (+), D0.2 (A)
unnamed: BT2.1 (+), D2.2 (A)
unnamed: BT2.2 (-), D0.1 (K)
unnamed: BT3.2 (-), D2.1 (K)
unnamed: D1.2 (A), R20.2
unnamed: D4.2 (A), J4.1 (VBUS)
unnamed: D5.1 (K), J1.6
unnamed: D6.2 (A), J6.2
unnamed: D7.2 (A), L1.2, U3.1 (SW)
unnamed: J2.17, RP1.5
unnamed: J2.18, RP1.6
unnamed: J2.19, RP1.7
unnamed: J2.20, RP1.8
unnamed: J2.21, RP2.5
unnamed: J2.22, RP2.6
unnamed: J2.23, RP2.7
unnamed: J2.24, RP2.8
unnamed: J2.25, RP6.1
unnamed: J2.26, RP6.2
unnamed: J2.27, RP6.3
unnamed: J2.28, RP6.4
unnamed: J2.29, RP5.1
unnamed: J2.30, RP5.2
unnamed: J2.31, RP5.3
unnamed: J2.32, RP5.4
unnamed: J2.35, RP4.1
unnamed: J2.36, RP4.2
unnamed: J2.37, RP4.3
unnamed: J2.38, RP4.4
unnamed: J2.44, RP3.1
unnamed: J2.45, RP3.2
unnamed: J2.46, RP3.3
unnamed: J2.47, RP3.4
unnamed: J4.2 (D-), R22.1
unnamed: J4.3 (D+), R21.1
unnamed: J4.4 (ID), R23.1
unnamed: R20.1, U1.84 (PTC12)
unnamed: U1.31 (XTAL32), Y1.1
unnamed: U1.32 (EXTAL32), Y1.2

Notes on the sheet:
RESET & Boot Selection
VDD Bypass Caps
Flash Memory
16bit DBI Type B Display Interface for ILI9488 Display Controller
24-pin FPC Camera Interface for OV5xxx - OV7xxx series cameras
Backlight Driver
Batteries
Power Switch
Micro USB
External Oscillator
Debug Interfaces

Board: 2 copper layers, 64.0 x 120.5 mm, 78 parts (5 on the bottom side), 114 nets.

## Commit log

2019-09-28 Initial rev with MK82 + LCD + camera
2019-09-28 Connect backlight supply to VREGIN
2019-09-28 Add external oscillator
2019-09-28 Add pull-up to JTAG_TRST and remove from header
2019-09-28 Rewire JTAG & UART to use 6-pin connectors
2019-09-28 Add alignment pins to LCD footprint
2019-09-28 Add r-packs to LCD signals to reduce EMI
2019-09-28 Reposition backlight driver
2019-09-28 Add board library cache

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
